# IAR project Catacomb.ewp, settings and files
configuration Debug (8051, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  General.OGChipSelectMenu: STC8H8K64U STC8H8K64U
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: D:\IAR_Project\Cadio_Catacomb3d\comm; D:\IAR_Project\Cadio_Catacomb3d\hardware; D:\IAR_Project\Cadio_Catacomb3d\graphic; D:\IAR_Project\Cadio_Catacomb3d\Arduboy3D
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 2
  XLINK.XclFile: D:\IAR_Project\Cadio_Catacomb3d\lnk51ew_STC8H8K64U.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
  group (top)
    ./: main.cpp
  group comm
    comm/: config.h STC8H.h TYPE.h
  group game
    Arduboy3D/: Draw.cpp Enemy.cpp Entity.cpp FixedMath.cpp Font.cpp Game.cpp Map.cpp MapGenerator.cpp Menu.cpp Particle.cpp Player.cpp Projectile.cpp Sounds.cpp
  group graphic
    graphic/: Graphic.c
  group hardware
    hardware/: ADC.C Key.c oled.c
